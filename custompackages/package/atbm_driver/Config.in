## custompackages/package/atbm_driver/Config.in
```kconfig
config BR2_PACKAGE_ATBM_DRIVER
	bool "atbm_driver"
	help
	  ATBM Wifi Driver custom build
```
